# Keil uVision project LCD.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LCD +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\LCD;..\HARDWARE\BEEP;..\HARDWARE\DHT11;..\SYSTEM\TIMER;..\HARDWARE\BH1750;..\NET\device;..\NET\MQTT;..\NET\onenet;..\NET\cJSON;..\HARDWARE\KEY;..\SYSTEM\EXTI;..\HARDWARE\OLED;..\HARDWARE\LB301;..\HARDWARE\LB301DY;..\HARDWARE\PWM;..\HARDWARE\MOTOR
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/BH1750/: bh1750.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/LB301/: LB301.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/MOTOR/: motor.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/TIMER/: timer.c
    ../STM32F10x_FWLib/src/: stm32f10x_exti.c
    ../SYSTEM/EXTI/: exti.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c
  group README
    ../: README.TXT
  group NET
    ../NET/MQTT/: MqttKit.c
    ../NET/onenet/: onenet.c
    ../NET/device/: esp8266.c
    ../NET/cJSON/: cJSON.c
